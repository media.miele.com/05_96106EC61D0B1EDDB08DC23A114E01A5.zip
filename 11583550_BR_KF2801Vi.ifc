Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-03-07T12:10:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 07 12:10:11 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\1b1c2eb1-ce95-4657-add8-96f3bddb242b\571a5954-52e5-433e-9a3b-a79c345c8dfb\ifc * Database version: 5507 * Database creation date: Tue Mar 07 12:10:10 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 07 12:10:11 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 07 12:10:11 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11583550_BR_KF2801Vi:38280102_BR_11583550_KF2801Vi, (2)
In: Default
Type - Material: z_Miele_Design_Powder Coat_Lotus White
Type - Pset_BuildingElementProxyCommon - Reference: 38280102_BR_11583550_KF2801Vi
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_QuantityTakeOff - Reference: 38280102_BR_11583550_KF2801Vi
Type - Pset_ProvisionForVoid - Width: 908 mm; Height: 2127 mm; Depth: 610 mm
Material: z_Miele_Design_Powder Coat_Lotus White, z_Miele_Design_GRGR, z_Miele_Design_Glass Black, z_Miele_Connection_Water_IN, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment

# IfcDistributionPort, Port_358026
Description: Flow; FlowDirection: SOURCEANDSINK
